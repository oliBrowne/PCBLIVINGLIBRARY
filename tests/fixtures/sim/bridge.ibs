| HAND-WRITTEN TEST FIXTURE (not a vendor IBIS model)
[IBIS Ver]   5.1
[File Name]   bridge.ibs
[File Rev]   0.1
[Date]   2026-10-14
[Component]   TPS1234
[Manufacturer]  ACME
[Package]
| variable   typ   min   max
R_pkg   0.2   0.1   0.3
L_pkg   2nH   1nH   3nH
C_pkg   1pF   0.5pF   1.5pF
[Pin]  signal_name  model_name  R_pin  L_pin  C_pin
1   P1   IO33
2   P2   IO33
3   P3   IN33
4   P4   GND
5   P5   POWER
6   P6   IO33
7   P7   IN33
8   P8   NC
[Model]   IO33
Model_type   I/O
Vinl = 0.8
Vinh = 2.0
[Model]   IN33
Model_type   Input
| Models and submodels in the file (2): IO33 (I/O), IN33 (Input)
